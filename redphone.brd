# Repository orangeneko/redphone-pcb

File README.md:

## About
Redphone - simple handmade open source mobile phone

## PCB

## Hardware
* Cortex M4 STM32F429NI
* FPGA EP4CE22U14I7N
* 800x480 LCD on RM68120 controller
* Capasitive LG P715 touch screen
* Memory (two SDRAM MT48LC16M16A2B4, MicroSD)
* Audio system based on (WM8903, MP34DT01 dmic, headphone, ring, minijack)
* Wi-Fi on ESP8266
* GSM & Bluetooth in SIM800H, nanosim (galaxy s8 sim-sd slot)
* Sensors (MPU9250, APDS-9960, BME280)
* GPS MC-1010-G
* OV5647 camera (Raspberry Pi compatible) & led
* Power domain (galaxy s4 battery, TPS65217)
* USB type-C for custom connections

## Software
* Latest linux kernel
* Firmware based on FreeRTOS, lwIP and Graphix (GUI C++ library)

## EAGLE design redphone.brd

Parts:
C2: 4.7u; R0603
C3: 0.1u, 6.3v; R0603
C4: 10u, 10v; R0805
C5, C53: 10u; R0805
C6, C7, C11, C12, C13, C16: 4.7u; R0805
C9: 1u; R0805
C10: 470u; SMC_D
C22, C23, C24, C25, C27, C28, C29, C42, C43, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C70, C71, C72, C73, C76, C77: 100n; R0402
IC7: TPS65217; VQFN-48
L1, L2, L3: 2.2uH; L2520
L4: 18uH; L2520
LOGO1, LOGO2: LOGO2
LOGO3: REDPHONE_LABLE
Q1: IRLML2502; SOT23
R4, R5, R35: 100k; R0402
R8, R36: 10k; R0402
R10, R11, R31, R34: 4.7k; R0402
SW2: SW-YD; YD-3414
TP3: TX; TP10R
TP4: RX; TP10R
VD1: DIODE-SOD123; SOD123
X1: USB; USB-TYPE-C-HYBRID

Connections:
1.2V: C7.1, C70.1, C72.1, C76.1, C77.1, IC7.43 (LDO4); also elsewhere on the board
2.5V: C6.1, C22.1, C23.1, IC7.40 (LDO3); also elsewhere on the board
3.3V: C11.1, C42.1, C43.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C71.1, C73.1, IC7.29 (VDCDC3), L3.2, Q1.3 (D); also elsewhere on the board
4.0V: C10.+, L2.2, R34.2; also elsewhere on the board
BAT_SENS: IC7.16 (MUX_OUT); also elsewhere on the board
GND: C2.1, C3.1, C4.1, C5.2, C6.2, C7.2, C9.2, C10.-, C11.2, C12.2, C13.2, C16.2, C22.2, C23.2, C24.2, C25.2, C27.2, C28.2, C29.2, C42.2, C43.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C70.2, C71.2, C72.2, C73.2, C76.2, C77.2, IC7.30 (PGND), IC7.41 (AGND), IC7.PAD (PGND), R5.1, R31.2, R36.1, SW2.1, SW2.4 (1), X1.A1 (GND1), X1.A12 (GND2), X1.B12 (GND4), X1.C1 (SHILD), X1.C2 (SHILD), X1.C3 (SHILD), X1.C4 (SHILD); also elsewhere on the board
I2C_SCL: IC7.28 (SCL), R11.1; also elsewhere on the board
I2C_SDA: IC7.27 (SDA), R10.2; also elsewhere on the board
LCD_BL_A: C2.2, IC7.38 (FB_WLED), VD1.C; also elsewhere on the board
LCD_BL_C: IC7.33 (ISINC2), IC7.34 (ISINC1); also elsewhere on the board
unnamed: IC7.31 (L3), L3.1
unnamed: IC7.23 (L2), L2.1
unnamed: IC7.20 (L1), L1.1
unnamed: IC7.37 (L4), L4.1, VD1.A
unnamed: IC7.35 (ISET1), R36.2
unnamed: IC7.24 (VDCDC2), R31.1, R34.1
unnamed: C3.2, IC7.48 (INT_LDO)
unnamed: C4.2, IC7.47 (BYPASS)
PWR_EN: IC7.9 (PWR_EN), R35.2; also elsewhere on the board
PWR_INT: IC7.45 (!INT); also elsewhere on the board
PWR_OTG_MODE: Q1.1 (G), R8.2; also elsewhere on the board
PWR_PB: IC7.25 (PB_IN), SW2.2, SW2.3 (2); also elsewhere on the board
PWR_WAKEUP: IC7.13 (!WAKEUP); also elsewhere on the board
SYS_SENS: IC7.14 (MUX_IN), R4.1, R5.2
USB_CC1: TP3.TP, X1.A5 (CC1); also elsewhere on the board
USB_CC2: TP4.TP, X1.B5 (CC2); also elsewhere on the board
USB_DM: X1.A7 (D-), X1.B7 (D-); also elsewhere on the board
USB_DP: X1.A6 (D+), X1.B6 (D+); also elsewhere on the board
USB_ID: X1.B1 (GND3); also elsewhere on the board
USB_RX0: X1.B11 (RX1+); also elsewhere on the board
USB_RX1: X1.B10 (RX1-); also elsewhere on the board
USB_RX2: X1.A11 (RX2+); also elsewhere on the board
USB_RX3: X1.A10 (RX2-); also elsewhere on the board
USB_SBU1: X1.A8 (SBU1); also elsewhere on the board
USB_SBU2: X1.B8 (SBU2); also elsewhere on the board
USB_TX0: X1.A2 (TX1+); also elsewhere on the board
USB_TX1: X1.A3 (TX1-); also elsewhere on the board
USB_TX2: X1.B2 (TX2+); also elsewhere on the board
USB_TX3: X1.B3 (TX2-); also elsewhere on the board
V_BAT: C9.1, IC7.4 (BAT), IC7.5 (BAT), IC7.6 (BAT_SENS); also elsewhere on the board
V_MCU: C12.1, C24.1, C25.1, C27.1, C28.1, C29.1, C54.1, IC7.18 (VIO), IC7.19 (VDCDC1), L1.2, R10.1, R11.2; also elsewhere on the board
V_SENS: C13.1, IC7.1 (VLDO2); also elsewhere on the board
V_SND: C16.1, IC7.3 (VLDO1); also elsewhere on the board
V_SYS: C53.1, IC7.2 (VINLDO), IC7.7 (SYS), IC7.8 (SYS), IC7.21 (VIN_DCDC1), IC7.22 (VIN_DCDC2), IC7.32 (VIN_DCDC3), IC7.39 (LDOIN3), IC7.42 (LDOIN4), L4.2, R4.2, R35.1
V_USB: C5.1, IC7.10 (AC), Q1.2 (S), R8.1, X1.A4 (VBUS), X1.A9 (VBUS), X1.B4 (VBUS), X1.B9 (VBUS)

Parts:
R12, R13: 4.7k; R0402
R48: 10k; R0402
R49: 100k; R0402
X3: RM68120_LCD; FH39-45S-0.3SHW
X5: LG_P715_TS; GB042-10S-H10-E3000

Connections:
3.3V: R12.1, R13.1, R48.1, R49.2, X3.5 (VCC), X3.6 (VCC), X5.7 (VCC_IO), X5.8 (VCC); also elsewhere on the board
GND: X3.1 (GND), X3.4 (GND), X3.35 (GND), X3.36 (IM1), X5.1 (GND), X5.5 (GND), X5.10 (GND); also elsewhere on the board
LCD_BL_A: X3.2 (VCC_BL); also elsewhere on the board
LCD_BL_C: X3.3 (GND_BL); also elsewhere on the board
LCD_CS: X3.39 (CS); also elsewhere on the board
LCD_PU0: R48.2, X3.37 (IM0), X3.38 (RST)
LCD_RD: X3.40 (RD); also elsewhere on the board
LCD_RS: X3.42 (RS); also elsewhere on the board
LCD_WR: X3.41 (WR/SCL); also elsewhere on the board
LTDC_B3: X3.22 (D11); also elsewhere on the board
LTDC_B4: X3.23 (D12); also elsewhere on the board
LTDC_B5: X3.24 (D13); also elsewhere on the board
LTDC_B6: X3.25 (D14); also elsewhere on the board
LTDC_B7: X3.26 (D15); also elsewhere on the board
LTDC_CLK: X3.9 (PCLK); also elsewhere on the board
LTDC_DE: X3.10 (DE); also elsewhere on the board
LTDC_G2: X3.16 (D5); also elsewhere on the board
LTDC_G3: X3.17 (D6); also elsewhere on the board
LTDC_G4: X3.18 (D7); also elsewhere on the board
LTDC_G5: X3.19 (D8); also elsewhere on the board
LTDC_G6: X3.20 (D9); also elsewhere on the board
LTDC_G7: X3.21 (D10); also elsewhere on the board
LTDC_HSYNC: X3.8 (HSYNC); also elsewhere on the board
LTDC_R3: X3.11 (D0); also elsewhere on the board
LTDC_R4: X3.12 (D1); also elsewhere on the board
LTDC_R5: X3.13 (D2); also elsewhere on the board
LTDC_R6: X3.14 (D3); also elsewhere on the board
LTDC_R7: X3.15 (D4); also elsewhere on the board
LTDC_VSYNC: X3.7 (VSYNC); also elsewhere on the board
TS_INT: R49.1, X5.4 (INT); also elsewhere on the board
TS_SCL: R13.2, X5.2 (SCL); also elsewhere on the board
TS_SDA: R12.2, X5.3 (SDA); also elsewhere on the board

Parts:
C8: 1F; R0805
C17: 100n; R0402
C30, C31: 4.7u; R0603
C32, C33, C34, C35: 22p; R0402
IC2: STM32F429NI; TFBGA216
QZ1: 8 MHz; 3225
QZ2: 32.768 KHz; 3215
R19, R26, R27, R28: 10k; R0402
R22: 10; R0402
TP1: IO; TP10R
TP2: CLK; TP10R
TP22: RST; TP10R
TP_PJ0: PJ0; TP10R
TP_PJ1: PJ1; TP10R
VD2: BAS516; SOD523

Connections:
AQ0: IC2.D2 (PF0); also elsewhere on the board
AQ1: IC2.E2 (PF1); also elsewhere on the board
AQ2: IC2.G2 (PF2); also elsewhere on the board
AQ3: IC2.H2 (PF3); also elsewhere on the board
AQ4: IC2.J2 (PF4); also elsewhere on the board
AQ5: IC2.K3 (PF5); also elsewhere on the board
AQ6: IC2.M6 (PF12); also elsewhere on the board
AQ7: IC2.N6 (PF13); also elsewhere on the board
AQ8: IC2.P6 (PF14); also elsewhere on the board
AQ9: IC2.M8 (PF15); also elsewhere on the board
AQ10: IC2.N7 (PG0); also elsewhere on the board
AQ11: IC2.M7 (PG1); also elsewhere on the board
AQ12: IC2.M13 (PG2); also elsewhere on the board
BAT_SENS: IC2.L1 (PF10); also elsewhere on the board
BL_CTRL: IC2.P4 (PA5); also elsewhere on the board
BL_RST: IC2.J1 (!RST), R26.2, TP22.TP; also elsewhere on the board
BQ0: IC2.N12 (PG4); also elsewhere on the board
BQ1: IC2.N11 (PG5); also elsewhere on the board
DQ0: IC2.L12 (PD14); also elsewhere on the board
DQ1: IC2.K13 (PD15); also elsewhere on the board
DQ2: IC2.B12 (PD0); also elsewhere on the board
DQ3: IC2.C12 (PD1); also elsewhere on the board
DQ4: IC2.R8 (PE7); also elsewhere on the board
DQ5: IC2.N9 (PE8); also elsewhere on the board
DQ6: IC2.P9 (PE9); also elsewhere on the board
DQ7: IC2.R9 (PE10); also elsewhere on the board
DQ8: IC2.P10 (PE11); also elsewhere on the board
DQ9: IC2.R10 (PE12); also elsewhere on the board
DQ10: IC2.R12 (PE13); also elsewhere on the board
DQ11: IC2.P11 (PE14); also elsewhere on the board
DQ12: IC2.R11 (PE15); also elsewhere on the board
DQ13: IC2.L15 (PD8); also elsewhere on the board
DQ14: IC2.L14 (PD9); also elsewhere on the board
DQ15: IC2.K15 (PD10); also elsewhere on the board
EPCS_!CS: IC2.B9 (PJ13); also elsewhere on the board
EPCS_ASDI: IC2.A8 (PB5); also elsewhere on the board
EPCS_DATA: IC2.A9 (PB4); also elsewhere on the board
EPCS_DCLK: IC2.A10 (PB3); also elsewhere on the board
ESP_CE: IC2.P13 (PH6); also elsewhere on the board
ESP_RX: IC2.P12 (PB10); also elsewhere on the board
ESP_TX: IC2.R13 (PB11); also elsewhere on the board
ETH_CRS_DV: IC2.R3 (PA7); also elsewhere on the board
ETH_MDC: IC2.M3 (PC1); also elsewhere on the board
ETH_MDIO: IC2.P2 (PA2); also elsewhere on the board
ETH_REF_CLK: IC2.N2 (PA1); also elsewhere on the board
ETH_RXD0: IC2.N5 (PC4); also elsewhere on the board
ETH_RXD1: IC2.P5 (PC5); also elsewhere on the board
ETH_TXD0: IC2.B3 (PG13); also elsewhere on the board
ETH_TXD1: IC2.A4 (PG14); also elsewhere on the board
ETH_TX_EN: IC2.B8 (PG11); also elsewhere on the board
FMC_!E1: IC2.A11 (PD7); also elsewhere on the board
FMC_!OE: IC2.D11 (PD4); also elsewhere on the board
FMC_!WE: IC2.C10 (PD5); also elsewhere on the board
FPGA_CLK: R22.1; also elsewhere on the board
FPGA_CONF_DONE: IC2.P3 (PA6); also elsewhere on the board
FPGA_IO0: IC2.K2 (PF6); also elsewhere on the board
FPGA_IO1: IC2.K1 (PF7); also elsewhere on the board
FPGA_IO2: IC2.L3 (PF8); also elsewhere on the board
FPGA_IO3: IC2.L2 (PF9); also elsewhere on the board
GND: C8.2, C17.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.1, IC2.F2 (VSS), IC2.F6 (VSS), IC2.F7 (VSS), IC2.F8 (VSS), IC2.F9 (VSS), IC2.F10 (VSS), IC2.G6 (VSS), IC2.G10 (VSS), IC2.H6 (VSS), IC2.H10 (VSS), IC2.J6 (VSS), IC2.J10 (VSS), IC2.K6 (VSS), IC2.K7 (VSS), IC2.K8 (VSS), IC2.K9 (VSS), IC2.K10 (VSS), IC2.L6 (VSS), IC2.M1 (VSSA), IC2.N1 (VREF-), QZ1.2 (GND), QZ1.4 (GND), R19.1, R27.1, R28.1; also elsewhere on the board
GSM_RX: IC2.H15 (PC6); also elsewhere on the board
GSM_TX: IC2.G15 (PC7); also elsewhere on the board
GSM_WAKEUP: IC2.J13 (PJ9); also elsewhere on the board
I2C_SCL: IC2.B6; also elsewhere on the board
I2C_SDA: IC2.B5 (PB7); also elsewhere on the board
LTDC_B3: IC2.D10 (PJ15); also elsewhere on the board
LTDC_B4: IC2.C3 (PI4); also elsewhere on the board
LTDC_B5: IC2.D3 (PI5); also elsewhere on the board
LTDC_B6: IC2.A7 (PB8); also elsewhere on the board
LTDC_B7: IC2.C5 (PK6); also elsewhere on the board
LTDC_CLK: IC2.H3 (PI14); also elsewhere on the board
LTDC_DE: IC2.C4 (PK7); also elsewhere on the board
LTDC_G2: IC2.E12 (PH13); also elsewhere on the board
LTDC_G3: IC2.C8 (PG10); also elsewhere on the board
LTDC_G4: IC2.D13 (PH15); also elsewhere on the board
LTDC_G5: IC2.E14 (PI0); also elsewhere on the board
LTDC_G6: IC2.D14 (PI1); also elsewhere on the board
LTDC_G7: IC2.C11 (PD3); also elsewhere on the board
LTDC_HSYNC: IC2.D5 (PI10); also elsewhere on the board
LTDC_R3: IC2.R5 (PB0); also elsewhere on the board
LTDC_R4: IC2.C15 (PA11); also elsewhere on the board
LTDC_R5: IC2.B15 (PA12); also elsewhere on the board
LTDC_R6: IC2.R4 (PB1); also elsewhere on the board
LTDC_R7: IC2.J15 (PG6); also elsewhere on the board
LTDC_VSYNC: IC2.E4 (PI9); also elsewhere on the board
MCO1: IC2.F15 (PA8), R22.2
unnamed: IC2.R6 (PJ0), TP_PJ0.TP
unnamed: C8.1, C17.1, IC2.C1 (VBAT), VD2.C
unnamed: IC2.L5 (BYPASS_REG), R19.2
unnamed: IC2.R7 (PJ1), TP_PJ1.TP
unnamed: C30.1, IC2.E11 (VCAP2)
unnamed: C31.1, IC2.L11 (VCAP1)
unnamed: IC2.E5 (PDR_ON), R28.2
OSC32I: C34.2, IC2.E1 (PC14/OSC32I), QZ2.2
OSC32O: C35.2, IC2.F1 (PC15/OSC32O), QZ2.1
OSCI: C32.2, IC2.G1 (PH0), QZ1.3 (2)
OSCO: C33.2, IC2.H1, QZ1.1
PWR_EN: IC2.B10 (PJ12); also elsewhere on the board
PWR_INT: IC2.C9 (PJ14); also elsewhere on the board
PWR_OTG_MODE: IC2.B11 (PD6); also elsewhere on the board
PWR_PB: IC2.J14 (PG7); also elsewhere on the board
PWR_WAKEUP: IC2.N3 (PA0); also elsewhere on the board
SAI_FSA: IC2.A1 (PE4); also elsewhere on the board
SAI_MCLK: IC2.A3 (PE2); also elsewhere on the board
SAI_SCKA: IC2.B1 (PE5); also elsewhere on the board
SAI_SDA: IC2.B2 (PE6); also elsewhere on the board
SAI_SDB: IC2.A2 (PE3); also elsewhere on the board
SDHC_ST: IC2.G13 (PK0); also elsewhere on the board
SDIO0: IC2.G14 (PC8); also elsewhere on the board
SDIO1: IC2.F14 (PC9); also elsewhere on the board
SDIO2: IC2.B14 (PC10); also elsewhere on the board
SDIO3: IC2.B13 (PC11); also elsewhere on the board
SDIO_CLK: IC2.A12 (PC12); also elsewhere on the board
SDIO_CMD: IC2.D12 (PD2); also elsewhere on the board
SDR_!CAS: IC2.B7 (PG15); also elsewhere on the board
SDR_!E0: IC2.J4 (PH3); also elsewhere on the board
SDR_!RAS: IC2.P8 (PF11); also elsewhere on the board
SDR_!WE: IC2.J3 (PH5); also elsewhere on the board
SDR_CKE0: IC2.K4 (PH2); also elsewhere on the board
SDR_CLK: IC2.H14 (PG8); also elsewhere on the board
SDR_NBL0: IC2.A6 (PE0); also elsewhere on the board
SDR_NBL1: IC2.A5 (PE1); also elsewhere on the board
SL_BOOT0: IC2.E6 (BOOT0), R27.2
SWD_CLK: IC2.A14, TP2.TP
SWD_IO: IC2.A15 (PA13), TP1.TP
SYS_LED0: IC2.M15 (PH12); also elsewhere on the board
SYS_LED1: IC2.N15 (PH11); also elsewhere on the board
TS_INT: IC2.P15 (PH10); also elsewhere on the board
TS_SCL: IC2.N13 (PH7); also elsewhere on the board
TS_SDA: IC2.P14 (PH8); also elsewhere on the board
USB_CC1: IC2.E15 (PA9); also elsewhere on the board
USB_CC2: IC2.D15 (PA10); also elsewhere on the board
USB_DM: IC2.R14 (PB14); also elsewhere on the board
USB_DP: IC2.R15 (PB15); also elsewhere on the board
USB_ID: IC2.L13 (PB12); also elsewhere on the board
VIBRO_CTRL: IC2.K14 (PB13); also elsewhere on the board
VOL_DOWN_PB: IC2.C2 (PI8); also elsewhere on the board
VOL_UP_PB: IC2.B4 (PB9); also elsewhere on the board
V_MCU: IC2.E7 (VDD), IC2.E8 (VDD), IC2.E9 (VDD), IC2.E10 (VDD), IC2.F4 (VDD), IC2.F5 (VDD), IC2.F11 (VDD), IC2.G5 (VDD), IC2.G11 (VDD), IC2.H5 (VDD), IC2.H11 (VDD), IC2.J5 (VDD), IC2.J11 (VDD), IC2.K5 (VDD), IC2.K11 (VDD), IC2.L7 (VDD), IC2.L8 (VDD), IC2.L9 (VDD), IC2.L10 (VDD), IC2.P1 (VREF+), IC2.R1 (VDDA), R26.1, VD2.A; also elsewhere on the board

Parts:
IC1: EP4CE22U14I7N; FBGA256
IC5: W25Q64FV; WSON8
R1, R2, R3, R53, R54, R55: 10k; R0402
R24: 50; R0402
TP21: TDO; TP10R
TP_CLK: CLK; TP10R
TP_DI: DI; TP10R

Connections:
1.2V: IC1.D4 (VCCD_PLL3), IC1.D13 (VCCD_PLL2), IC1.F7 (VCCINT), IC1.F11 (VCCINT), IC1.G6 (VCCINT), IC1.G7 (VCCINT), IC1.G8 (VCCINT), IC1.G9 (VCCINT), IC1.G10 (VCCINT), IC1.H6 (VCCINT), IC1.H11 (VCCINT), IC1.J6 (VCCINT), IC1.J12 (VCCINT), IC1.K7 (VCCINT), IC1.K9 (VCCINT), IC1.K10 (VCCINT), IC1.K11 (VCCINT), IC1.L6 (VCCINT), IC1.M9 (VCCINT), IC1.M11 (VCCINT), IC1.N4 (VCCD_PLL1), IC1.N13 (VCCD_PLL4); also elsewhere on the board
2.5V: IC1.F5 (VCCA3), IC1.F12 (VCCA2), IC1.L5 (VCCA1), IC1.L12 (VCCA4); also elsewhere on the board
3.3V: IC1.A1 (VCCIO8), IC1.A16 (VCCIO7), IC1.C4 (VCCIO8), IC1.C7 (VCCIO8), IC1.C10 (VCCIO7), IC1.C13 (VCCIO7), IC1.E3 (VCCIO1), IC1.E14 (VCCIO6), IC1.G3 (VCCIO1), IC1.G14 (VCCIO6), IC1.H12 (MSEL1), IC1.K3 (VCCIO2), IC1.K14 (VCCIO5), IC1.M3 (VCCIO2), IC1.M14 (VCCIO5), IC1.P4 (VCCIO3), IC1.P7 (VCCIO3), IC1.P10 (VCCIO4), IC1.P13 (VCCIO4), IC1.T1 (VCCIO3), IC1.T16 (VCCIO4), IC5.3 (!WP!/IO2), IC5.7 (!HOLD!/IO3), IC5.8 (VCC), R1.1, R2.1, R3.1, R54.1, R55.1; also elsewhere on the board
AQ0: IC1.E8 (IO_3); also elsewhere on the board
AQ1: IC1.D8 (IO_2); also elsewhere on the board
AQ2: IC1.C8 (IO_1); also elsewhere on the board
AQ3: IC1.C9 (IO_20); also elsewhere on the board
AQ4: IC1.D9 (IO_21); also elsewhere on the board
AQ5: IC1.E10 (IO_10); also elsewhere on the board
AQ6: IC1.C11 (IO_15); also elsewhere on the board
AQ7: IC1.B16 (IO_6); also elsewhere on the board
BL_RST: IC1.L3 (IO_7); also elsewhere on the board
DQ0: IC1.D6 (IO_14); also elsewhere on the board
DQ1: IC1.E6 (IO_11); also elsewhere on the board
DQ2: IC1.C6 (IO_7); also elsewhere on the board
DQ3: IC1.D5 (IO_19); also elsewhere on the board
DQ4: IC1.E7 (IO_10); also elsewhere on the board
DQ5: IC1.C3 (IO_21); also elsewhere on the board
DQ6: IC1.F3 (IO_4); also elsewhere on the board
DQ7: IC1.D3 (IO_22); also elsewhere on the board
DQ8: IC1.F14 (IO_7); also elsewhere on the board
DQ9: IC1.E9 (IO_22); also elsewhere on the board
DQ10: IC1.E11 (IO_9); also elsewhere on the board
DQ11: IC1.D12 (IO_4); also elsewhere on the board
DQ12: IC1.F13 (IO_3); also elsewhere on the board
DQ13: IC1.D11 (IO_3); also elsewhere on the board
DQ14: IC1.D14 (IO_2); also elsewhere on the board
DQ15: IC1.C14 (IO_1); also elsewhere on the board
EPCS_!CS: IC1.D2 (IO_5), IC5.1 (!CS); also elsewhere on the board
EPCS_ASDI: IC1.C1 (IO_3), IC5.5 (MOSI/IO0), TP_DI.TP; also elsewhere on the board
EPCS_DATA: IC1.H2 (IO_12), IC5.2 (MISO/IO1); also elsewhere on the board
EPCS_DCLK: IC1.H1 (DCLK), IC5.6 (SCK), TP_CLK.TP; also elsewhere on the board
ESP_CE: IC1.N9 (IO_1); also elsewhere on the board
ESP_RX: IC1.P6 (IO_11); also elsewhere on the board
ESP_TX: IC1.N8 (IO_22); also elsewhere on the board
ETH_CRS_DV: IC1.J13 (IO_16); also elsewhere on the board
ETH_MDC: IC1.J14 (IO_15); also elsewhere on the board
ETH_MDIO: IC1.N5 (IO_8); also elsewhere on the board
ETH_REF_CLK: IC1.K5 (IO_10); also elsewhere on the board
ETH_RXD0: IC1.N6 (IO_9); also elsewhere on the board
ETH_RXD1: IC1.M6 (IO_10); also elsewhere on the board
ETH_TXD0: IC1.L7 (IO_17); also elsewhere on the board
ETH_TXD1: IC1.L8 (IO_20); also elsewhere on the board
ETH_TX_EN: IC1.L14 (IO_7); also elsewhere on the board
FMC_!E1: IC1.M7 (IO_12); also elsewhere on the board
FMC_!OE: IC1.M8 (IO_21); also elsewhere on the board
FMC_!WE: IC1.L13 (IO_8); also elsewhere on the board
FPGA_!CONFIG: IC1.H5 (!CONFIG), R2.2
FPGA_!STATUS: IC1.F4 (!STATUS), R1.2
FPGA_CLK: IC1.E1 (CLK1), R24.1; also elsewhere on the board
FPGA_CONF_DONE: IC1.H14 (CONF_DONE), R3.2; also elsewhere on the board
FPGA_IO0: IC1.F8 (IO_4); also elsewhere on the board
FPGA_IO1: IC1.F9 (IO_17); also elsewhere on the board
FPGA_IO2: IC1.L4 (IO_11); also elsewhere on the board
FPGA_IO3: IC1.G5 (IO_7); also elsewhere on the board
GND: IC1.B2 (GND), IC1.B15 (GND), IC1.C5 (GND), IC1.C12 (GND), IC1.D7 (GND), IC1.D10 (GND), IC1.E2 (GND), IC1.E4 (GND), IC1.E5 (GNDA3), IC1.E12 (GNDA2), IC1.E13 (GND), IC1.F6 (GND), IC1.F10 (GND), IC1.G4 (GND), IC1.G11 (GND), IC1.G12 (MSEL2), IC1.G13 (GND), IC1.H7 (GND), IC1.H8 (GND), IC1.H9 (GND), IC1.H10 (GND), IC1.H13 (MSEL0), IC1.H15 (GND), IC1.H16 (GND), IC1.J3 (!CE), IC1.J7 (GND), IC1.J8 (GND), IC1.J9 (GND), IC1.J10 (GND), IC1.J11 (GND), IC1.K4 (GND), IC1.K6 (GND), IC1.K8 (GND), IC1.K12 (GND), IC1.K13 (GND), IC1.L9 (GND), IC1.L10 (GND), IC1.L11 (GND), IC1.M4 (GND), IC1.M5 (GNDA1), IC1.M12 (GNDA4), IC1.M13 (GND), IC1.N7 (GND), IC1.N10 (GND), IC1.P5 (GND), IC1.P12 (GND), IC1.R2 (GND), IC1.R15 (GND), IC5.4 (GND), R24.2, R53.1; also elsewhere on the board
GPS_RX: IC1.M2 (CLK2); also elsewhere on the board
GPS_TX: IC1.M1 (CLK3); also elsewhere on the board
GSM_PCM_CLK: IC1.N12 (IO_16); also elsewhere on the board
GSM_PCM_IN: IC1.P14 (IO_17); also elsewhere on the board
GSM_PCM_OUT: IC1.N11 (IO_13); also elsewhere on the board
GSM_PCM_SYNC: IC1.N14 (IO_1); also elsewhere on the board
GSM_RX: IC1.P11 (IO_9); also elsewhere on the board
GSM_TX: IC1.M10 (IO_12); also elsewhere on the board
JTAG_TCK: IC1.H3 (TCK), R53.2
JTAG_TDI: IC1.H4 (TDI), R54.2
JTAG_TDO: IC1.J4 (TDO), TP21.TP
JTAG_TMS: IC1.J5 (TMS), R55.2
LCD_CS: IC1.A2 (IO_17); also elsewhere on the board
LCD_RD: IC1.A4 (IO_15); also elsewhere on the board
LCD_RS: IC1.B4 (IO_16); also elsewhere on the board
LCD_WR: IC1.B1 (IO_1); also elsewhere on the board
LTDC_B3: IC1.B6 (IO_9); also elsewhere on the board
LTDC_B4: IC1.A3 (IO_18); also elsewhere on the board
LTDC_B5: IC1.A5 (IO_12); also elsewhere on the board
LTDC_B6: IC1.B3 (IO_20); also elsewhere on the board
LTDC_B7: IC1.B5 (IO_13); also elsewhere on the board
LTDC_CLK: IC1.B11 (IO_14); also elsewhere on the board
LTDC_DE: IC1.B9 (CLK9); also elsewhere on the board
LTDC_G2: IC1.A7 (IO_5); also elsewhere on the board
LTDC_G3: IC1.A12 (IO_11); also elsewhere on the board
LTDC_G4: IC1.B7 (IO_6); also elsewhere on the board
LTDC_G5: IC1.D1 (IO_6); also elsewhere on the board
LTDC_G6: IC1.A6 (IO_8); also elsewhere on the board
LTDC_G7: IC1.C2 (IO_2); also elsewhere on the board
LTDC_HSYNC: IC1.A9 (CLK8); also elsewhere on the board
LTDC_R3: IC1.A10 (IO_18); also elsewhere on the board
LTDC_R4: IC1.A8 (CLK10); also elsewhere on the board
LTDC_R5: IC1.B10 (IO_19); also elsewhere on the board
LTDC_R6: IC1.B8 (CLK11); also elsewhere on the board
LTDC_R7: IC1.B12 (IO_12); also elsewhere on the board
LTDC_VSYNC: IC1.A11 (IO_13); also elsewhere on the board
OV_CLK: IC1.N2 (IO_8); also elsewhere on the board
OV_D0: IC1.F2 (IO_8); also elsewhere on the board
OV_D1: IC1.F1 (IO_9); also elsewhere on the board
OV_D2: IC1.G2 (IO_10); also elsewhere on the board
OV_D3: IC1.G1 (IO_11); also elsewhere on the board
OV_D4: IC1.J2 (IO_1); also elsewhere on the board
OV_D5: IC1.J1 (IO_2); also elsewhere on the board
OV_D6: IC1.K2 (IO_3); also elsewhere on the board
OV_D7: IC1.K1 (IO_4); also elsewhere on the board
OV_D8: IC1.L2 (IO_5); also elsewhere on the board
OV_D9: IC1.L1 (IO_6); also elsewhere on the board
OV_HSYNC: IC1.P1 (IO_14); also elsewhere on the board
OV_PCLK: IC1.N1 (IO_9); also elsewhere on the board
OV_PD: IC1.R1 (IO_12); also elsewhere on the board
OV_VSYNC: IC1.P2 (IO_13); also elsewhere on the board
PWR_PB: IC1.T2 (IO_5); also elsewhere on the board
SAI_FSA: IC1.B13 (IO_6); also elsewhere on the board
SAI_MCLK: IC1.B14 (IO_8); also elsewhere on the board
SAI_SCKA: IC1.A13 (IO_5); also elsewhere on the board
SAI_SDA: IC1.A15 (IO_16); also elsewhere on the board
SAI_SDB: IC1.A14 (IO_7); also elsewhere on the board
SDRAM_!CAS: IC1.M16 (CLK7); also elsewhere on the board
SDRAM_!CS: IC1.D16 (IO_8); also elsewhere on the board
SDRAM_!RAS: IC1.F15 (IO_5); also elsewhere on the board
SDRAM_!WE: IC1.E16 (CLK5); also elsewhere on the board
SDRAM_A0: IC1.N16 (IO_5); also elsewhere on the board
SDRAM_A1: IC1.D15 (IO_9); also elsewhere on the board
SDRAM_A2: IC1.C15 (IO_11); also elsewhere on the board
SDRAM_A3: IC1.N15 (IO_6); also elsewhere on the board
SDRAM_A4: IC1.P16 (IO_3); also elsewhere on the board
SDRAM_A5: IC1.T7 (IO_19); also elsewhere on the board
SDRAM_A6: IC1.P15 (IO_2); also elsewhere on the board
SDRAM_A7: IC1.R8 (CLK15); also elsewhere on the board
SDRAM_A8: IC1.T8 (CLK14); also elsewhere on the board
SDRAM_A9: IC1.R16 (IO_4); also elsewhere on the board
SDRAM_A10: IC1.C16 (IO_10); also elsewhere on the board
SDRAM_A11: IC1.R9 (CLK13); also elsewhere on the board
SDRAM_A12: IC1.T9 (CLK12); also elsewhere on the board
SDRAM_B0: IC1.M15 (CLK6); also elsewhere on the board
SDRAM_B1: IC1.E15 (CLK4); also elsewhere on the board
SDRAM_CKE: IC1.T15 (IO_15); also elsewhere on the board
SDRAM_CLK: IC1.R10 (IO_2); also elsewhere on the board
SDRAM_D0: IC1.L15 (IO_10); also elsewhere on the board
SDRAM_D1: IC1.K16 (IO_11); also elsewhere on the board
SDRAM_D2: IC1.L16 (IO_9); also elsewhere on the board
SDRAM_D3: IC1.J16 (IO_13); also elsewhere on the board
SDRAM_D4: IC1.K15 (IO_12); also elsewhere on the board
SDRAM_D5: IC1.G16 (IO_1); also elsewhere on the board
SDRAM_D6: IC1.J15 (IO_14); also elsewhere on the board
SDRAM_D7: IC1.F16 (IO_4); also elsewhere on the board
SDRAM_D8: IC1.T11 (IO_5); also elsewhere on the board
SDRAM_D9: IC1.R11 (IO_4); also elsewhere on the board
SDRAM_D10: IC1.T12 (IO_7); also elsewhere on the board
SDRAM_D11: IC1.R12 (IO_6); also elsewhere on the board
SDRAM_D12: IC1.T13 (IO_11); also elsewhere on the board
SDRAM_D13: IC1.R13 (IO_10); also elsewhere on the board
SDRAM_D14: IC1.T14 (IO_14); also elsewhere on the board
SDRAM_D15: IC1.R14 (IO_18); also elsewhere on the board
SDRAM_DQMH: IC1.T10 (IO_3); also elsewhere on the board
SDRAM_DQML: IC1.G15 (IO_2); also elsewhere on the board
TS_INT: IC1.R7 (IO_18); also elsewhere on the board
TS_SCL: IC1.P9 (IO_8); also elsewhere on the board
TS_SDA: IC1.P8 (IO_23); also elsewhere on the board
USB_RX0: IC1.R3 (IO_3); also elsewhere on the board
USB_RX1: IC1.T3 (IO_4); also elsewhere on the board
USB_RX2: IC1.R6 (IO_15); also elsewhere on the board
USB_RX3: IC1.T6 (IO_16); also elsewhere on the board
USB_SBU1: IC1.N3 (IO_1); also elsewhere on the board
USB_SBU2: IC1.P3 (IO_2); also elsewhere on the board
USB_TX0: IC1.R4 (IO_6); also elsewhere on the board
USB_TX1: IC1.T4 (IO_7); also elsewhere on the board
USB_TX2: IC1.R5 (IO_13); also elsewhere on the board
USB_TX3: IC1.T5 (IO_14); also elsewhere on the board
