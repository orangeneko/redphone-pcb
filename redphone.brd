# Repository orangeneko/redphone-pcb (continued)

## EAGLE design redphone.brd (continued)

Parts:
IC3: MT48LC16M16A2B4; VFBGA-54; MPN MT48LC16M16A2P-6A
IC4: MT48LC16M16A2B4; VFBGA-54

Connections:
3.3V: IC3.A7 (VDDQ), IC3.A9 (VDD), IC3.B3 (VDDQ), IC3.C7 (VDDQ), IC3.D3 (VDDQ), IC3.E7 (VDD), IC3.J9 (VDD), IC4.A7 (VDDQ), IC4.A9 (VDD), IC4.B3 (VDDQ), IC4.C7 (VDDQ), IC4.D3 (VDDQ), IC4.E7 (VDD), IC4.J9 (VDD); also elsewhere on the board
AQ0: IC3.H7 (A0); also elsewhere on the board
AQ1: IC3.H8 (A1); also elsewhere on the board
AQ2: IC3.J8 (A2); also elsewhere on the board
AQ3: IC3.J7 (A3); also elsewhere on the board
AQ4: IC3.J3 (A4); also elsewhere on the board
AQ5: IC3.J2 (A5); also elsewhere on the board
AQ6: IC3.H3 (A6); also elsewhere on the board
AQ7: IC3.H2 (A7); also elsewhere on the board
AQ8: IC3.H1 (A8); also elsewhere on the board
AQ9: IC3.G3 (A9); also elsewhere on the board
AQ10: IC3.H9 (A10); also elsewhere on the board
AQ11: IC3.G2 (A11); also elsewhere on the board
AQ12: IC3.G1 (A12); also elsewhere on the board
BQ0: IC3.G7 (B0); also elsewhere on the board
BQ1: IC3.G8 (B1); also elsewhere on the board
DQ0: IC3.A8 (DQ0); also elsewhere on the board
DQ1: IC3.B9 (DQ1); also elsewhere on the board
DQ2: IC3.B8 (DQ2); also elsewhere on the board
DQ3: IC3.C9 (DQ3); also elsewhere on the board
DQ4: IC3.C8 (DQ4); also elsewhere on the board
DQ5: IC3.D9 (DQ5); also elsewhere on the board
DQ6: IC3.D8 (DQ6); also elsewhere on the board
DQ7: IC3.E9 (DQ7); also elsewhere on the board
DQ8: IC3.E1 (DQ8); also elsewhere on the board
DQ9: IC3.D2 (DQ9); also elsewhere on the board
DQ10: IC3.D1 (DQ10); also elsewhere on the board
DQ11: IC3.C2 (DQ11); also elsewhere on the board
DQ12: IC3.C1 (DQ12); also elsewhere on the board
DQ13: IC3.B2 (DQ13); also elsewhere on the board
DQ14: IC3.B1 (DQ14); also elsewhere on the board
DQ15: IC3.A2 (DQ15); also elsewhere on the board
GND: IC3.A1 (VSS), IC3.A3 (VSSQ), IC3.B7 (VSSQ), IC3.C3 (VSSQ), IC3.D7 (VSSQ), IC3.E3 (VSS), IC3.J1 (VSS), IC4.A1 (VSS), IC4.A3 (VSSQ), IC4.B7 (VSSQ), IC4.C3 (VSSQ), IC4.D7 (VSSQ), IC4.E3 (VSS), IC4.J1 (VSS); also elsewhere on the board
SDRAM_!CAS: IC4.F7 (!CAS); also elsewhere on the board
SDRAM_!CS: IC4.G9 (!CS); also elsewhere on the board
SDRAM_!RAS: IC4.F8 (!RAS); also elsewhere on the board
SDRAM_!WE: IC4.F9 (!WE); also elsewhere on the board
SDRAM_A0: IC4.H7 (A0); also elsewhere on the board
SDRAM_A1: IC4.H8 (A1); also elsewhere on the board
SDRAM_A2: IC4.J8 (A2); also elsewhere on the board
SDRAM_A3: IC4.J7 (A3); also elsewhere on the board
SDRAM_A4: IC4.J3 (A4); also elsewhere on the board
SDRAM_A5: IC4.J2 (A5); also elsewhere on the board
SDRAM_A6: IC4.H3 (A6); also elsewhere on the board
SDRAM_A7: IC4.H2 (A7); also elsewhere on the board
SDRAM_A8: IC4.H1 (A8); also elsewhere on the board
SDRAM_A9: IC4.G3 (A9); also elsewhere on the board
SDRAM_A10: IC4.H9 (A10); also elsewhere on the board
SDRAM_A11: IC4.G2 (A11); also elsewhere on the board
SDRAM_A12: IC4.G1 (A12); also elsewhere on the board
SDRAM_B0: IC4.G7 (B0); also elsewhere on the board
SDRAM_B1: IC4.G8 (B1); also elsewhere on the board
SDRAM_CKE: IC4.F3 (CKE); also elsewhere on the board
SDRAM_CLK: IC4.F2 (CLK); also elsewhere on the board
SDRAM_D0: IC4.A8 (DQ0); also elsewhere on the board
SDRAM_D1: IC4.B9 (DQ1); also elsewhere on the board
SDRAM_D2: IC4.B8 (DQ2); also elsewhere on the board
SDRAM_D3: IC4.C9 (DQ3); also elsewhere on the board
SDRAM_D4: IC4.C8 (DQ4); also elsewhere on the board
SDRAM_D5: IC4.D9 (DQ5); also elsewhere on the board
SDRAM_D6: IC4.D8 (DQ6); also elsewhere on the board
SDRAM_D7: IC4.E9 (DQ7); also elsewhere on the board
SDRAM_D8: IC4.E1 (DQ8); also elsewhere on the board
SDRAM_D9: IC4.D2 (DQ9); also elsewhere on the board
SDRAM_D10: IC4.D1 (DQ10); also elsewhere on the board
SDRAM_D11: IC4.C2 (DQ11); also elsewhere on the board
SDRAM_D12: IC4.C1 (DQ12); also elsewhere on the board
SDRAM_D13: IC4.B2 (DQ13); also elsewhere on the board
SDRAM_D14: IC4.B1 (DQ14); also elsewhere on the board
SDRAM_D15: IC4.A2 (DQ15); also elsewhere on the board
SDRAM_DQMH: IC4.F1 (DQMH); also elsewhere on the board
SDRAM_DQML: IC4.E8 (DQML); also elsewhere on the board
SDR_!CAS: IC3.F7 (!CAS); also elsewhere on the board
SDR_!E0: IC3.G9 (!CS); also elsewhere on the board
SDR_!RAS: IC3.F8 (!RAS); also elsewhere on the board
SDR_!WE: IC3.F9 (!WE); also elsewhere on the board
SDR_CKE0: IC3.F3 (CKE); also elsewhere on the board
SDR_CLK: IC3.F2 (CLK); also elsewhere on the board
SDR_NBL0: IC3.E8 (DQML); also elsewhere on the board
SDR_NBL1: IC3.F1 (DQMH); also elsewhere on the board

Parts:
C1, C15, C66, C67: 100n; R0402
C14: 10u; SMC_A
C19, C20: 10p; R0402
C65: 10nF; R0402
C68: 47u, 6.3v; R0805
C69: 4.7u; R0603
C75: 3n; R0402
IC6: SIM800H
IC13: W25Q64FV; WSON8
IC14: MC-1010-G
IC15: MAX2659; UDFN6
IC18: ESP32; QFN48-6X6
L5: G; LED0603
L6: 1nH; R0402
QZ3: 26 MHz; 2520
R15, R37: 1k; R0402
R16: 20k; R0402
R21: 330; R0402
R23: 100k; R0402
TP23: FM; TP10R
TP24: PPS; TP10R
TP_ESP_TCK: TCK; TP10R
TP_ESP_TDI: TDI; TP10R
TP_ESP_TDO: TDO; TP10R
TP_TMS: TMS; TP10R
VD5: Y; LED0603
VD7: G; LED0603
Y1: 2.4Ghz; ANTENNA_CHIP_2X9
Y2: ANTENNA_CHIP2X9; ANTENNA_CHIP_2X9
Y3: 2.4Ghz; ANTENNA_CHIP_2X5
Y4: GSM_PCB; GSM_ANT

Connections:
3.3V: C1.1, C14.+, C15.1, C67.1, IC13.8 (VCC), IC14.6 (V_BCKP), IC14.8 (VCC), IC18.1 (VDDA), IC18.3 (VDD3P3), IC18.4 (VDD3P3), IC18.19 (VDD3P3_RTC), IC18.26 (VDD_SDIO), IC18.37 (VDD3P3_CPU), IC18.43 (VDDA), IC18.46 (VDDA); also elsewhere on the board
4.0V: C68.1, IC6.1 (VBAT), IC6.42 (VBAT); also elsewhere on the board
ESP_CE: IC18.9 (CE); also elsewhere on the board
ESP_RX: IC18.40 (GPIO3/U0RXD); also elsewhere on the board
ESP_TX: IC18.41 (GPIO1/U0TXD); also elsewhere on the board
GND: C1.2, C14.-, C15.2, C19.1, C20.1, C65.2, C66.1, C67.2, C68.2, C69.2, IC6.2 (GND), IC6.6 (GND), IC6.8 (GND), IC6.10 (MIC2N), IC6.11 (SPK2N), IC6.12 (MIC1N), IC6.13 (SPK1N), IC6.35 (GND), IC6.37 (GND), IC6.38 (GND), IC6.39 (GND), IC6.41 (GND), IC6.43 (GND), IC6.44 (GND), IC6.45 (GND), IC6.48 (PWRKEY), IC6.57 (FM_ANT_N), IC6.58 (GND), IC6.67 (GND), IC6.71 (GND), IC6.72 (GND), IC6.73 (GND), IC13.4 (GND), IC14.1 (GND), IC14.10 (GND), IC14.12 (GND), IC15.1 (GND), IC15.2 (GND), IC18.EP (GND), L5.C, QZ3.2 (GND), QZ3.4 (GND), R23.1, VD5.C, VD7.C, Y4.GND; also elsewhere on the board
GPS_RX: IC14.3 (RX); also elsewhere on the board
GPS_TX: IC14.2 (TX); also elsewhere on the board
GSM_A_IN: IC6.52 (MIC1P); also elsewhere on the board
GSM_A_OUT: IC6.53 (SPK1P); also elsewhere on the board
GSM_BT_RF: IC6.36 (BT_ANT), Y3.FEED
GSM_NL: IC6.64 (NETLIGHT), R15.2
GSM_PCM_CLK: IC6.29 (PCMCLK); also elsewhere on the board
GSM_PCM_IN: IC6.66 (PCMIN); also elsewhere on the board
GSM_PCM_OUT: IC6.30 (PCMOUT); also elsewhere on the board
GSM_PCM_SYNC: IC6.65 (PCMSYNC); also elsewhere on the board
GSM_RF: IC6.40 (GSM_ANT), Y4.S
GSM_RX: IC6.31 (RXD); also elsewhere on the board
GSM_ST: IC6.4 (STATUS), R37.2
GSM_TX: IC6.32 (TXD); also elsewhere on the board
GSM_WAKEUP: IC6.69 (DTR); also elsewhere on the board
unnamed: C66.2, IC14.14 (VCC_RF), IC15.4 (VCC), IC15.5 (!SHDN)
unnamed: IC14.4 (1PPS), TP24.TP
unnamed: IC6.17 (FM_ANT_P), TP23.TP
unnamed: C69.1, IC6.56 (VRTC)
unnamed: IC14.11 (RF_IN), IC15.6 (RF_OUT)
unnamed: IC15.3 (RF_IN), Y2.FEED
unnamed: R37.1, VD7.A
unnamed: C65.1, C75.1, IC18.48 (CAP1), R16.1
unnamed: IC18.2 (LNA_IN), L6.1
unnamed: C19.2, IC18.44 (XTALN), QZ3.3 (2)
unnamed: C20.2, IC18.45 (XTALP), QZ3.1
unnamed: IC18.21 (GPIO15/TDO), R23.2, TP_ESP_TDO.TP
unnamed: L5.A, R21.2
unnamed: C75.2, IC18.47 (CAP2), R16.2
unnamed: IC18.17 (GPIO14/TMS), TP_TMS.TP
unnamed: IC18.18 (GPIO12/TDI), TP_ESP_TDI.TP
unnamed: IC18.20 (GPIO13/TCK), TP_ESP_TCK.TP
unnamed: IC18.34 (GPIO5), R21.1
unnamed: L6.2, Y1.FEED
unnamed: R15.1, VD5.A
SDHC_ST: IC6.54 (SIMPRE); also elsewhere on the board
SD_!HD!: IC13.7 (!HOLD!/IO3), IC18.28 (GPIO9/SPIHD)
SD_!WP!: IC13.3 (!WP!/IO2), IC18.29 (GPIO10/SPIWP)
SD_CLK: IC13.6 (SCK), IC18.31 (GPIO6/SPICLK)
SD_CS0: IC13.1 (!CS), IC18.30 (GPIO11/SPICS0)
SD_SI: IC13.5 (MOSI/IO0), IC18.33 (GPIO8/SPID)
SD_SO: IC13.2 (MISO/IO1), IC18.32 (GPIO7/SPIQ)
SIM_CLK: IC6.55 (SIM_CLK); also elsewhere on the board
SIM_DATA: IC6.14 (SIM_DATA); also elsewhere on the board
SIM_RST: IC6.15 (SIM_RST); also elsewhere on the board
SIM_VDD: IC6.16 (VSIM); also elsewhere on the board

Parts:
B1: SPEAKER_NOKIA_RING; NOKIA_820_RING
B2: SPEAKER_HTC_ONE; HTC_ONE_S_SPEAKER
C36, C45, C46: 2.2u; R0603
C37, C38, C44: 4.7u; R0603
C39, C40, C41, C47, C48: 100n; R0402
C49, C50, C51, C52: 1u; R0603
IC9: WM8903; QFN40-5X5
IC16: MP34DT01; HCLGA
R29, R30, R32, R33: 20; R0402
R40, R41: 2.2k; R0402
X7: AUDIO-JACKSMD; PJ-342

Connections:
3.3V: IC16.3 (LR), IC16.4 (VCC); also elsewhere on the board
AUDIO_INT: IC9.5 (INT)
DMIC_CLK: IC9.4 (DMIC_LR/GPIO1), IC16.2 (CLK)
DMIC_DAT: IC9.3 (DMIC_DAT/GPIO2), IC16.1 (DOUT)
GND: C37.1, C38.1, C41.2, C44.1, C45.1, C46.1, C49.2, C50.2, IC9.1 (DGND), IC9.12 (CPGND), IC9.17 (HPGND), IC9.20 (LINEGND), IC9.26 (AGND), IC9.EXP (AGND), IC16.GND@1 (GND), IC16.GND@2 (GND), IC16.GND@3 (GND), IC16.GND@4 (GND), R29.2, R30.2, R32.2, R33.2, X7.1; also elsewhere on the board
GSM_A_IN: C48.2, IC9.21 (LINEOUTL); also elsewhere on the board
GSM_A_OUT: C51.1, R41.2; also elsewhere on the board
HL: C39.2, IC9.18 (HPOUTL), X7.3
HR: C40.2, IC9.16 (HPOUTER), X7.4
I2C_SCL: IC9.37 (SCLK); also elsewhere on the board
I2C_SDA: IC9.36 (SDIN); also elsewhere on the board
JACK_MIC: C52.1, R40.2, X7.2
MIC_PWR: C37.2, IC9.29 (MICBIAS), R40.1, R41.1
unnamed: C36.1, IC9.11 (CFB1)
unnamed: C36.2, IC9.13 (CFB2)
unnamed: C52.2, IC9.31 (IN2R)
unnamed: C38.2, IC9.25 (VMID)
unnamed: C40.1, R29.1
unnamed: C39.1, R30.1
unnamed: C47.1, R33.1
unnamed: C48.1, R32.1
unnamed: C45.2, IC9.15 (VNEG)
unnamed: C46.2, IC9.14 (VPOS)
unnamed: C47.2, IC9.19 (LINEOUTR)
unnamed: C49.1, IC9.35 (IN1L)
unnamed: C51.2, IC9.32 (IN1R)
unnamed: C50.1, IC9.34 (IN2L)
RING1: B1.1; also elsewhere on the board
RING2: B1.2; also elsewhere on the board
RINGN: IC9.27 (RON); also elsewhere on the board
RINGP: IC9.28 (ROP); also elsewhere on the board
SAI_FSA: IC9.8 (LRC); also elsewhere on the board
SAI_MCLK: IC9.2 (MCLK); also elsewhere on the board
SAI_SCKA: IC9.6 (BCLK); also elsewhere on the board
SAI_SDA: IC9.7 (DACDAT); also elsewhere on the board
SAI_SDB: IC9.9 (ADCDAT); also elsewhere on the board
SPKRN: IC9.23 (LON); also elsewhere on the board
SPKRN2: B2.1; also elsewhere on the board
SPKRP: IC9.22 (LOP); also elsewhere on the board
SPKRP2: B2.2; also elsewhere on the board
V_SND: C41.1, C44.2, IC9.10 (CPVDD), IC9.24 (AVDD), IC9.39 (DCVDD), IC9.40 (DBVDD); also elsewhere on the board

Parts:
C18, C26, C64, C74: 100n; R0402
C21: 4.7u; SMC_A
IC10: MPU9250; QFN24-3X3
IC11: PCA9633TK; HVSON8
IC12: BME280
IC17: APDS-9960
R6, R7, R9: 330; R0402
VD6: LED3; LED1204
X2: OV5647; DF30FC-24DS-0.4V

Connections:
1.2V: X2.5 (DVDD); also elsewhere on the board
2.5V: X2.7 (AVDD); also elsewhere on the board
3.3V: X2.6 (DOVDD); also elsewhere on the board
3.3V2: C64.1, IC11.8 (VCC), IC17.5 (LEDA), IC17.8 (VDD), VD6.4 (A); also elsewhere on the board
GND: C18.2, C21.-, C26.2, C74.2, IC10.11 (FSYNC), IC10.18 (GND), IC10.20 (GND), IC12.1 (GND), IC12.5 (SDO), IC12.7 (GND), X2.8 (GND), X2.10 (GND), X2.12 (GND); also elsewhere on the board
GND2: C64.2, IC11.5 (GND), IC17.6 (GND); also elsewhere on the board
I2C_SCL: IC10.23 (SCL), IC12.4 (SCK), X2.14 (SCL); also elsewhere on the board
I2C_SDA: IC10.24 (SDA/SDI), IC12.3 (SDI), X2.13 (SDA); also elsewhere on the board
unnamed: IC17.3 (LDR), IC17.4 (LEDK)
unnamed: R6.2, VD6.1 (CG)
unnamed: R7.2, VD6.2 (CB)
unnamed: R9.2, VD6.3 (CR)
unnamed: IC11.2 (LED1), R6.1
unnamed: IC11.1 (LED0), R7.1
unnamed: C26.1, IC10.10 (REGOUT)
unnamed: IC11.3 (LED2), R9.1
NAV_I2C_SCL2: IC11.6 (SCL), IC17.7 (SCL); also elsewhere on the board
NAV_I2C_SDA2: IC11.7 (SDA), IC17.1 (SDA); also elsewhere on the board
NAV_INT0: IC10.12 (INT)
OV_CLK: X2.11 (XCLK); also elsewhere on the board
OV_D0: X2.24 (Y0); also elsewhere on the board
OV_D1: X2.23 (Y1); also elsewhere on the board
OV_D2: X2.22 (Y2); also elsewhere on the board
OV_D3: X2.21 (Y3); also elsewhere on the board
OV_D4: X2.20 (Y4/MDP1); also elsewhere on the board
OV_D5: X2.19 (Y5/MDN1); also elsewhere on the board
OV_D6: X2.18 (Y6/MCP); also elsewhere on the board
OV_D7: X2.17 (Y7/MCN); also elsewhere on the board
OV_D8: X2.16 (Y8/MDP0); also elsewhere on the board
OV_D9: X2.15 (Y9/MDN0); also elsewhere on the board
OV_HSYNC: X2.2 (HREF); also elsewhere on the board
OV_PCLK: X2.9 (PCLK); also elsewhere on the board
OV_PD: X2.1 (PWDN); also elsewhere on the board
OV_VSYNC: X2.3 (VSYNC); also elsewhere on the board
V_SENS: C18.1, C21.+, C74.1, IC10.1 (VDDIO), IC10.8 (VDDIO), IC10.9 (AD0/SDO), IC10.13 (VDD), IC10.22 (!CS), IC12.2 (CSB), IC12.6 (VDDIO), IC12.8 (VDD); also elsewhere on the board

Schematic: redphone.sch, sheet 9, Con/SW/Leds

Parts:
M1: VIBRO; VIBRO_4X4X10
Q2, Q3: IRLML2502; SOT-416
Q4: IRLML2502; SOT23
R14, R44: 330; R0402
R38: 10k; R0402
SW3, SW4: SW-YD; YD-3414
TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP54, TP55, TP58, TP59, TP60, TP61, TP62, TP63, TP64, TP66, TP67, TP68, TP69, TP70, TP71, TP72, TP73, TP74, TP75, TP77, TP78, TP79, TP80, TP81, TP82: TP_HOLE; TP065RH
VD3: R; LED0603
VD4: G; LED0603
VD8: LED6030
X4: MICRO_SIM_SDS8; SAMSUNG_S8_SIM_SD

Connections:
3.3V: Q4.2 (S), R38.1, TP11.1; also elsewhere on the board
3.3V2: TP79.1; also elsewhere on the board
BL_CTRL: TP10.1; also elsewhere on the board
BL_CTRL2: Q2.1 (G), TP7.1
GND: SW3.1, SW3.4 (1), SW4.1, SW4.4 (1), TP12.1, TP54.1, TP55.1, TP59.1, TP60.1, TP61.1, TP62.1, VD3.C, VD4.C, X4.C6 (GND), X4.D2 (GND), X4.G1 (GND), X4.G2 (GND), X4.G3 (GND), X4.G4 (GND), X4.G5 (GND), X4.G6 (GND), X4.GND, X4.S4 (GND); also elsewhere on the board
GND2: TP73.1; also elsewhere on the board
GND2_MDL: Q2.2 (S), Q3.2 (S), TP9.1
GND_BAT: TP70.1, TP71.1, TP72.1
I2C_SCL: TP67.1; also elsewhere on the board
I2C_SDA: TP66.1; also elsewhere on the board
unnamed: M1.1, Q3.3 (D)
unnamed: Q2.3 (D), VD8.C
unnamed: Q4.3 (D), X4.C4 (VCC), X4.S1 (VCC)
unnamed: R44.1, VD3.A
unnamed: R14.1, VD4.A
NAV_I2C_SCL2: TP78.1; also elsewhere on the board
NAV_I2C_SDA2: TP77.1; also elsewhere on the board
RING1: TP18.1; also elsewhere on the board
RING2: TP17.1; also elsewhere on the board
RINGN: TP13.1; also elsewhere on the board
RINGP: TP14.1; also elsewhere on the board
SDHC_ST: Q4.1 (G), R38.2, X4.D1 (ST); also elsewhere on the board
SDIO0: X4.C7 (DAT0/MISO); also elsewhere on the board
SDIO1: X4.C8 (DAT1); also elsewhere on the board
SDIO2: X4.C1 (DAT2); also elsewhere on the board
SDIO3: X4.C2 (DAT3/CS); also elsewhere on the board
SDIO_CLK: X4.C5 (CLK); also elsewhere on the board
SDIO_CMD: X4.C3 (CMD/MOSI); also elsewhere on the board
SIM_CLK: X4.S3 (CLK); also elsewhere on the board
SIM_DATA: X4.S6 (I/O); also elsewhere on the board
SIM_RST: X4.S2 (RST); also elsewhere on the board
SIM_VDD: X4.S5 (VPP); also elsewhere on the board
SPKRN: TP64.1; also elsewhere on the board
SPKRN2: TP80.1; also elsewhere on the board
SPKRP: TP63.1; also elsewhere on the board
SPKRP2: TP81.1; also elsewhere on the board
SYS_LED0: R44.2; also elsewhere on the board
SYS_LED1: R14.2; also elsewhere on the board
VCC2_MDL: M1.2, TP8.1, VD8.A
VIBRO_CTRL: TP20.1; also elsewhere on the board
VIBRO_CTRL2: Q3.1 (G), TP19.1
VOL_DOWN_PB: SW4.2, SW4.3 (2); also elsewhere on the board
VOL_UP_PB: SW3.2, SW3.3 (2); also elsewhere on the board
V_BAT: TP58.1; also elsewhere on the board
V_BAT2: TP69.1
V_SENS: TP68.1; also elsewhere on the board

Notes on the sheet:
SPKR_HOLDER
BAT_HOLDER
SENS_HOLDER
BAT_HOLDER_MDL
SENS_HOLDER_MDL
SPKR_HOLDER_MDL

Board: 4 copper layers, 145.9 x 65.0 mm, 231 parts (12 on the bottom side), 326 nets.

## Commit log

2017-06-06 updated cap & res values
2017-06-06 added first pcb draft
2017-06-06 first test release
2017-06-06 routed sound, type-c, pwr, added lcd dc-dc
2017-06-06 update type-c, codec pkg, route
2017-06-06 added gsm ant, usb type-c, new charger ic
2017-06-06 added gnd holes for 3.3 dc-dc
2017-06-06 update route of gnd polygons
2017-06-06 connect rtc to vbat, change mosfet type
2017-06-06 new pkg of wifi's crystall
2017-06-06 i2c & cts tps, cap pkg fix, names fix, route fix
2017-06-06 upd route, pwr: pullup CEN, EP to GND, cap for NC(4) pin of IC6, R58 for IC13
2017-06-06 new modem dc-dc
2017-06-06 fix size of pads on speaker
2017-06-06 new 1.2/2.5 dc-dc, fix bad pinout on audiocodec
2017-06-06 fix mosfets
2017-06-06 fix VDD_RTC on wifi chip
2017-06-06 fix charger schematic
2017-06-06 new sensor MPU9250, moved light sensor and routed pcb for new ts
2017-06-06 added gps, combine sim and sd slots in one
2017-06-06 upd route, new pwr logic
2017-06-06 upd route, fix mdl connectors
2017-06-06 new battery connection mechanism
2017-06-06 touch, sd connector fix, route fix
2017-06-06 led pwm controller, new lcd connector
2017-06-06 swap usb_cc1 to mcu_rst
2017-06-06 move ts connector
2017-06-06 added ds18b20, udfn pack for eeprom, some route fix
2017-06-06 change fpga crystal to osc, update lbr
2017-06-06 touch keyboard backlight, changed BAT_SENS input
2017-06-06 lowdrop en ctrl from stm
2017-06-06 fix battary connector
2017-06-06 route & schematic fix, connect PWR_BUT to fpga, new IO89 tp
2017-06-06 fix pkg of gps lna, cap & res values fix, drc fix
2017-06-06 label upd, added more tps, route fix, dfc fix, round corners
2017-06-06 fix dimension, silk, mdl connectors, added extra tps & led on 3.3v
2017-06-06 fix MPU9250 pkg
2017-07-01 swap EPCS pins, added res
2017-07-07 connect lcd dc-dc to V_INT, connect AQ13 to FPGA
2018-04-22 start rerouting
2018-05-06 new stm32, cyclone4, spi-flash packeges
2018-05-25 new rpi cam, pwr mgmt, sim connector, update placement
2018-05-29 sdram routing template
2018-06-03 template lines of pwr, modem, audio, sd
2018-06-03 pwr layer update
2018-06-03 ltdc connection template
2018-06-05 ltcd, eth, usb, lcd route template
2018-06-08 cam route
2018-06-08 new ltdc route template
2018-06-15 sai route template
2018-06-15 bga alingment
2018-06-15 fpga boot nand route, some nets update
2018-06-17 usb route, added V_SND
2018-06-17 added pwr ctrl pins, update route
2018-06-17 route eps & sens
2018-06-18 connected lcd to fpga
2018-06-18 connected cam to fpga
2018-07-13 update .gitignore for ignoring autorouter files
2018-07-13 fpga connection template
2018-08-05 fpga routed
2018-08-10 pwr route, volume buttons connect
2018-08-12 fix some & routing nets & polys, added ring speaker
2018-08-13 pwr caps, fix gnd pad of some ICs, connect leds
2018-08-18 mcu rst (reassigned fpga pins), led for cam, various pcb parts
2018-08-21 drc fix, some opt
2018-09-07 added vibro, flashlight, gps, silk update
2018-09-10 fix sim & sd slot, light & vibro mdl, layouts
2018-09-16 update drc (vias, distance), fix warns & silk, added some tps, res & cap
2018-09-16 update gerbers, doc
2018-12-26 values layer update
2019-03-28 added PU on PWR_ON, divider for VDCDC2, changed i2c res vcc
2019-03-28 added hole for sim-sd connector
2019-07-28 fix DCDC2 res
2019-07-29 added ISET1 res, USB pwr input is AC now
2019-08-20 updeted LCD connector, connected 35 pin to GND
2019-10-27 remove bat & bat connector, update chip ant silk, added led for modem status
2019-10-29 pwr refactoring, auto pwr disable for sim-sd
2020-06-15 now used new type of buttons
2020-06-16 added some testpoints
2020-06-17 esp8266 was replaced by esp32
